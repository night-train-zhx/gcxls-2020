# Keil uVision project w.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: w +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\core;..\user;..\fwlib\inc;..\system\delay;..\system\sys;..\system\usart;..\hardware;..\VL53L0X\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../core/: startup_stm32f40_41xxx.s core_cm4.h
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c smooth.txt
  group usart
    ../HARDWARE/: usart1.c usart2.c usart3.c uart4.c usart6.c
  group hardware
    ../HARDWARE/: systick.c key.c oled.c iic.c vl53l0x.c motor.c dj.c
    ../hardware/: led.c
  group ctrl
    ../HARDWARE/: motor_ctrl.c dj_ctrl.c ctrl.c schedule.c
  group vl53l0
    ../VL53L0X/src/: vl53l0x_platform.c vl53l0x_i2c.c vl53l0x_api_strings.c vl53l0x_api_ranging.c vl53l0x_api_core.c vl53l0x_api_calibration.c vl53l0x_api.c
  group system
    ../system/sys/: sys.c
  group fwlib
    ../fwlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
